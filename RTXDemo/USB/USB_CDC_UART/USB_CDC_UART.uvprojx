# Keil uVision project USB_CDC_UART.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_CDC_UART
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: USBD_User_CDC_ACM_UART_0.c main.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS Driver:USB Device:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, USB:CORE 6.15.0, USB:Device 6.15.0, USB:Device:CDC 6.15.0, CMSIS Driver:USART 1.0, CMSIS Driver:USB Device 1.0, Device:DMA 1.0, Device:GPIO 1.0, Device:Startup 1.0.0
