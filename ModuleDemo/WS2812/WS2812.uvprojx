# Keil uVision project WS2812.uvprojx, settings and files
target WS2812 (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WS2812
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\WS2812;..\..\Libraries\AIR32F10xLib\inc;..\..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c WS2812.c
    ../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group CORE
    ../../Libraries/STARTUP/arm/: startup_air32f10x.s
  group FWLib
    ../../Libraries/AIR32F10xLib/src/: air32f10x_dma.c air32f10x_gpio.c air32f10x_rcc.c air32f10x_spi.c
