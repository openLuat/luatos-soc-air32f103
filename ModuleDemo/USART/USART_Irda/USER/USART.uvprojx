# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c air32f10x_it.c
    ../../../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_air32f10x.s
  group FWLib
    ../../../../Libraries/AIR32F10xLib/src/: misc.c air32f10x_usart.c air32f10x_rcc.c air32f10x_gpio.c air32f10x_crc.c
