# Keil uVision project COREMARK.uvprojx, settings and files
target coremark (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: COREMARK
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\..\..\..\Libraries\AIR32F10xLib\lib;..\third_party\coremark;..\..\..\..\Libraries\AIR32F10xLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Core
    ./: main.c air32f10x_it.c
  group System
    ../SYSTEM/delay/: delay.c
  group third_party
    ../third_party/coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group FWlib
    ../../../../Libraries/AIR32F10xLib/src/: misc.c air32f10x_rcc.c air32f10x_adc.c air32f10x_bkp.c air32f10x_can.c air32f10x_crc.c air32f10x_dac.c air32f10x_dbgmcu.c air32f10x_dma.c air32f10x_exti.c air32f10x_fsmc.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_iwdg.c air32f10x_otp.c air32f10x_pwr.c air32f10x_rtc.c air32f10x_sdio.c air32f10x_spi.c air32f10x_tim.c air32f10x_trng.c air32f10x_usart.c air32f10x_wwdg.c air32f10x_rcc_ex.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
