# Keil uVision project USB.uvprojx, settings and files
target USB (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Libraries\AIR32F10xLib\inc;..\SYSTEM\led;..\SYSTEM\delay;..\USER;..\USB\CONFIG;..\USB\air32_USB-FS-Device_Driver\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\AIR32F10xLib\lib;..\..\..\..\ModuleDemo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./: main.c air32f10x_it.c
    ../SYSTEM/delay/: delay.c
  group Startup
    ../../../../Libraries/STARTUP/arm/: startup_air32f10x.s
  group StdPeriph_Driver
    ../../../../Libraries/AIR32F10xLib/src/: air32f10x_gpio.c air32f10x_rcc.c air32f10x_exti.c air32f10x_tim.c air32f10x_usart.c air32f10x_iwdg.c air32f10x_wwdg.c air32f10x_bkp.c air32f10x_pwr.c air32f10x_adc.c air32f10x_dac.c air32f10x_dma.c air32f10x_rtc.c air32f10x_can.c misc.c
  group CMSIS
    ../../../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group USB_CORE
    ../USB/air32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../../../../Libraries/AIR32F10xLib/src/: air32f10x_rcc_ex.c
