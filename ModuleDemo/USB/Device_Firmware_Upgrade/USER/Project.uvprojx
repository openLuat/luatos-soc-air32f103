# Keil uVision project Project.uvprojx, settings and files
target USB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.0.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DFU +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\USER;..\USB\CONFIG;..\USB\air32_USB-FS-Device_Driver\inc;..\..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: main.c air32f10x_it.c
  group Startup
    ../../../../Libraries/STARTUP/arm/: startup_air32f10x.s
  group CMSIS
    ../../../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group StdPeriph_Driver
    ../../../../Libraries/AIR32F10xLib/src/: air32f10x_rcc.c air32f10x_gpio.c misc.c air32f10x_exti.c air32f10x_pwr.c air32f10x_flash.c air32f10x_dma.c
  group USB_CORE
    ../USB/air32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: dfu_mal.c flash_if.c opt_if.c hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
software components: CMSIS:CORE 5.5.0
