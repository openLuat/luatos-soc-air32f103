# Keil uVision project nes.uvprojx, settings and files
target nes (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nes
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=5 wLevel=3
  c include: ..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\Libraries\CMSIS\Include;..\project;.\driver;..\rt-thread\include;..\rt-thread\include\libc;.\board;..\rt-thread\components\finsh;..\nes\inc;..\nes\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ./: main.c air32f10x_it.c
  group startup
    C:/Users/qq147/Desktop/air32f103/Libraries/STARTUP/arm/: startup_air32f10x.s
  group lib
    C:/Users/qq147/Desktop/air32f103/Libraries/AIR32F10xLib/src/: air32f10x_exti.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_usart.c misc.c system_air32f10x.c air32f10x_dma.c air32f10x_spi.c air32f10x_gpio.c
  group nes
    ../nes/src/: nes.c nes_apu.c nes_cpu.c nes_mapper.c nes_ppu.c nes_rom.c
    ../nes/src/nes_mapper/: nes_mapper0.c nes_mapper2.c
    ../nes/port/: nes_port.c
  group driver
    ./driver/: st7789.c
  group board
    ./board/: board.c drv_clock.c
  group kernel
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group finsh
    ../rt-thread/components/finsh/: cmd.c finsh.h finsh_api.h finsh_config.h finsh_port.c msh.c msh.h shell.c shell.h
  group device
    ../rt-thread/components/device/: device.c
  group libcpu
    ../rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
