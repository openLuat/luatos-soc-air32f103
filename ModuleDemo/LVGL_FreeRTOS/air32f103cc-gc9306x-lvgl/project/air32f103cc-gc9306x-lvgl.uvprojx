# Keil uVision project air32f103cc-gc9306x-lvgl.uvprojx, settings and files
target single-buffer (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR32F103CC Generic
  pack: Keil.AIR32F103_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: air32f103cc-gc9306x-lvgl +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c include: ..\main;..\components\bsp;..\components\lvgl;..\components\lvgl_port;..\components\lvgl\demos;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\..\Libraries\AIR32F10xLib\lib;..\components\FreeRTOS-Kernel\include;..\components\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../main/: main.c lvgl_task.c idle_task.c led_task.c lv_conf.h air32f10x_conf.h FreeRTOSConfig.h
  group bsp
    ../components/bsp/: bsp_lcd.c bsp_led.c
  group lvgl
    ../components/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../components/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../components/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../components/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../components/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../components/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../components/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../components/lvgl/src/extra/: lv_extra.c
    ../components/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../components/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../components/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../components/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../components/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../components/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../components/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../components/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../components/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../components/lvgl/src/extra/widgets/led/: lv_led.c
    ../components/lvgl/src/extra/widgets/list/: lv_list.c
    ../components/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../components/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../components/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../components/lvgl/src/extra/widgets/span/: lv_span.c
    ../components/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../components/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../components/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../components/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl_port
    ../components/lvgl_port/: lv_port_tick.c lv_port_disp.c
  group lvgl_demo_benchmark
    ../components/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../components/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group core
    ../main/: startup_air32f10x.s
  group driver
    ../../../../Libraries/AIR32F10xLib/src/: air32f10x_adc.c air32f10x_bkp.c air32f10x_can.c air32f10x_crc.c air32f10x_dac.c air32f10x_dbgmcu.c air32f10x_dma.c air32f10x_exti.c air32f10x_flash.c air32f10x_fsmc.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_iwdg.c air32f10x_otp.c air32f10x_pwr.c air32f10x_rcc.c air32f10x_rtc.c air32f10x_sdio.c air32f10x_spi.c air32f10x_tim.c air32f10x_trng.c air32f10x_usart.c air32f10x_wwdg.c misc.c air32f10x_rcc_ex.c
  group FreeRTOS
    ../components/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../components/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
target double-buffer (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR32F103CC Generic
  pack: Keil.AIR32F103_DFP.1.1.0
  cpu: as above
  output: air32f103cc-gc9306x-lvgl +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE,CONFIG_LVGL_USE_DOUBLE_BUFF
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
