# Keil uVision project RCC.uvprojx, settings and files
target RCC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.0.6
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RCC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CORE;..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\Libraries\AIR32F10xLib\lib;..\..\..\Libraries\AIR32F10xLib\lib\cryptlib;.\cryptlibTest
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c air32f10x_it.c
    ../../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../Libraries/CORE/: core_cm3.c
    ../../../Libraries/STARTUP/arm/: startup_air32f10x.s
  group cryptlib
    ../../../Libraries/AIR32F10xLib/lib/cryptlib/: air_crypt.lib
  group crypt_test
    ./cryptlibTest/: aes_self_test.c aes_time_test.c debug.c des_self_test.c des_time_test.c rand_self_test.c sha_self_test.c sha_time_test.c sm1_self_test.c sm1_time_test.c sm3_self_test.c sm3_time_test.c sm4_self_test.c sm4_time_test.c sm7_self_test.c sm7_time_test.c air_cephes.c air_bignum_tool.c
  group FWlib
    ../../../Libraries/AIR32F10xLib/src/: air32f10x_adc.c air32f10x_bkp.c air32f10x_can.c air32f10x_crc.c air32f10x_dac.c air32f10x_dbgmcu.c air32f10x_dma.c air32f10x_exti.c air32f10x_flash.c air32f10x_fsmc.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_iwdg.c air32f10x_otp.c air32f10x_pwr.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_rtc.c air32f10x_sdio.c air32f10x_spi.c air32f10x_tim.c air32f10x_trng.c air32f10x_usart.c air32f10x_wwdg.c misc.c
