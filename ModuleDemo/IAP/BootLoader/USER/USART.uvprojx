# Keil uVision project USART.uvprojx, settings and files
target BootLoader (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,AIR32F103CB
  c include: ..\USER;..\..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\SYSTEM\iap
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c air32f10x_it.c
    ../../../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
    ../SYSTEM/iap/: common.c download.c ymodem.c
  group CORE
    ../../../../Libraries/STARTUP/arm/: startup_air32f10x.s
  group FWLib
    ../../../../Libraries/AIR32F10xLib/src/: misc.c air32f10x_usart.c air32f10x_rcc.c air32f10x_gpio.c air32f10x_crc.c air32f10x_dma.c air32f10x_flash.c air32f10x_exti.c
