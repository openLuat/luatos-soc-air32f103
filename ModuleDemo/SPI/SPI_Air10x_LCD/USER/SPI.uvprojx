# Keil uVision project SPI.uvprojx, settings and files
target SPI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\SYSTEM\st7735v;..\..\..\..\Libraries\AIR32F10xLib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c air32f10x_it.c
    ../../../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/st7735v/: st7735v.c
  group CORE
    ../../../../Libraries/STARTUP/arm/: startup_air32f10x.s
  group FWLib
    ../../../../Libraries/AIR32F10xLib/src/: misc.c air32f10x_rcc.c air32f10x_gpio.c air32f10x_usart.c air32f10x_spi.c air32f10x_rcc_ex.c
