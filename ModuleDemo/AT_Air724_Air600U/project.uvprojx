# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: rt-thread\components\net\sal\impl;rt-thread\components\drivers\include;board;rt-thread\components\net\sal\include\socket;board\ports;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\include;libraries\AIR32F10xLib\inc;rt-thread\components\net\sal\include;applications;rt-thread\components\libc\compilers\common\extension;libraries\CMSIS\Include;rt-thread\components\net\netdev\include;rt-thread\components\net\at\at_socket;packages\at_device-latest\class\air720;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;.;rt-thread\components\finsh;libraries;rt-thread\components\net\at\include;rt-thread\components\libc\posix\io\stdio;packages\at_device-latest\inc;libraries\rt_drivers;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\libc\posix\io\poll
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_client.c at_cli.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/samples/: at_sample_air720.c
    packages/at_device-latest/class/air720/: at_device_air720.c at_socket_air720.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    libraries/AIR32F10xLib/src/: air32f10x_adc.c air32f10x_bkp.c air32f10x_can.c air32f10x_crc.c air32f10x_dac.c air32f10x_dbgmcu.c air32f10x_dma.c air32f10x_exti.c air32f10x_flash.c air32f10x_fsmc.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_iwdg.c air32f10x_otp.c air32f10x_pwr.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_rtc.c air32f10x_sdio.c air32f10x_spi.c air32f10x_tim.c air32f10x_trng.c air32f10x_usart.c air32f10x_wwdg.c misc.c system_air32f10x.c
    libraries/Startup/arm/: startup_air32f10x.s
    libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c
    rt-thread/components/net/sal/src/: sal_socket.c
