# Keil uVision project freertos.uvprojx, settings and files
target freertos (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\AIR32F10xLib\inc;..\..\Libraries\CMSIS\Include;.\FreeRTOS-Kernel\include;..\FreeRTOS;.\FreeRTOS-Kernel\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c
  group CORE
    ./: startup_air32f10x.s
  group FWLib
    ../../Libraries/AIR32F10xLib/src/: air32f10x_dma.c air32f10x_gpio.c air32f10x_rcc.c air32f10x_spi.c air32f10x_rcc_ex.c air32f10x_usart.c misc.c
  group freertos
    ./FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ./FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
